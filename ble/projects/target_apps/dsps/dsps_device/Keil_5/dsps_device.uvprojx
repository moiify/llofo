# Keil uVision project dsps_device.uvprojx, settings and files
target dsps_585 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: dacode
  AfterMake: after.bat
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt" --via ble_micro.opt
  c include: .\..\..\..\..\..\SDK_585\\sdk\\platform\include;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\api;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_bass;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_diss;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_suotar;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_custs;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\controller\em;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\controller\llc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\controller\lld;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\controller\llm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\hcic;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\hcih;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\att;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\att\attc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\att\attm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\att\atts;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gap;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gap\gapc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gap\gapm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gatt;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gatt\gattc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gatt\gattm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\smp\smpc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\smp\smpm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\smp;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\rwble;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\rwble_hl;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\ea\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\em\api;.\..\..\..\..\..\SDK_585\\sdk\\common_project_files;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch\boot\rvds;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch\compiler\rvds;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch\ll\rvds;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch\main;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\arch_console;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\common\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\crypto;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\dbg\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\gtl\src;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\ke\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\ke\src;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\nvds\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\rf\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\gtl\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\rwip\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\wlan_coex;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\h4tl\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\adc;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\battery;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\gpio;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\i2c_eeprom;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\reg;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\spi;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\spi_flash;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\syscntl;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\systick;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\trng;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\uart;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\wkupct_quadec;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\ble;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\emi;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\intc;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\hw_otpc;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\dma;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\pdm;.\..\src\config;.\..\src;..\..\..\..\..\SDK_585\\sdk\\platform\system_library\include;..\src\custom_profile;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\api\app_proxr;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\hci\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\hci\src;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\custom;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\custom\custs\api;..\..\common\src\driver;..\..\common\src\profiles;..\..\common\src\;..\..\common\src\profiles\spss;..\..\..\..\..\SDK_585\sdk\common_project_files;..\src\user_lib
  library: MicroLIB
  scatter file: .\..\..\..\..\..\SDK_585\\sdk\\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\SDK_585\\sdk\\common_project_files\misc\da14585_symbols.txt  --symdefs=dsps_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../../SDK_585//sdk//platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../../../../../SDK_585//sdk//platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../../SDK_585//sdk//platform/core_modules/arch_console/: arch_console.c
    ./../../../../../SDK_585//sdk//platform/core_modules/nvds/src/: nvds.c
    ./../../../../../SDK_585//sdk//platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c
    ../../../../../SDK_585//sdk//platform/arch/main/: arch_rom.c
  group sdk_driver
    ./../../../../../SDK_585//sdk//platform/driver/syscntl/: syscntl.c
    ./../../../../../SDK_585//sdk//platform/driver/gpio/: gpio.c
    ./../../../../../SDK_585//sdk//platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../../../SDK_585//sdk//platform/driver/battery/: battery.c
    ./../../../../../SDK_585//sdk//platform/driver/adc/: adc.c
    ./../../../../../SDK_585//sdk//platform/driver/trng/: trng.c
    ./../../../../../SDK_585//sdk//platform/driver/spi_flash/: spi_flash.c
    ./../../../../../SDK_585//sdk//platform/driver/spi/: spi.c
    ./../../../../../SDK_585//sdk//platform/driver/systick/: systick.c
    ./../../../../../SDK_585//sdk//platform/driver/uart/: uart2.c
    ../../../../../SDK_585//sdk//platform/driver/hw_otpc/: hw_otpc.c
    ../../../../../SDK_585/sdk/platform/driver/uart/: uart1.c
    ../src/: timer0.c timer2.c timer0.h
  group sdk_ble
    ./../../../../../SDK_585//sdk//platform/core_modules/rf/src/: rf_585.c
    ./../../../../../SDK_585//sdk//ble_stack/rwble/: rwble.c
    ./../../../../../SDK_585//sdk//platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    ./../../../../../SDK_585//sdk//ble_stack/host/att/attm/: attm_db_128.c
    ./../../../../../SDK_585//sdk//ble_stack/profiles/custom/: custom_common.c
    ../../../../../SDK_585//sdk//ble_stack/profiles/: prf.c
    ./../../../../../SDK_585//sdk//ble_stack/profiles/: prf_utils.c
  group sdk_app
    ./../../../../../SDK_585//sdk//app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../../../SDK_585//sdk//app_modules/src/app_common/: app.c app_task.c app_msg_utils.c
    ./../../../../../SDK_585//sdk//app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../../../../../SDK_585//sdk//app_modules/src/app_entry/: app_entry_point.c
    ./../../../../../SDK_585//sdk//app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ./../../../../../SDK_585//sdk//app_modules/src/app_custs/: app_customs.c app_customs_common.c
  group sdk_driver_api
    ./../../../../../SDK_585//sdk//platform/driver/adc/: adc.h
    ./../../../../../SDK_585//sdk//platform/driver/battery/: battery.h
    ./../../../../../SDK_585//sdk//platform/driver/gpio/: gpio.h
    ./../../../../../SDK_585//sdk//platform/driver/i2c_eeprom/: i2c_eeprom.h
    ./../../../../../SDK_585//sdk//platform/driver/spi/: spi.h
    ./../../../../../SDK_585//sdk//platform/driver/spi_flash/: spi_flash.h
    ./../../../../../SDK_585//sdk//platform/driver/systick/: systick.h
    ./../../../../../SDK_585//sdk//platform/driver/trng/: trng.h
    ./../../../../../SDK_585//sdk//platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    ./../../../../../SDK_585//sdk//app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    ./../../../../../SDK_585//sdk//platform/arch/main/: arch_wdg.h
    ./../../../../../SDK_585//sdk//platform/arch/: arch_api.h
    ./../../../../../SDK_585//sdk//platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../../common/src/profiles/spss/: sps_server.c sps_server_task.c
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_sps_device.c user_spss.c user_spss_task.c user_timer.c uart1_router.c setting.c local_event.c ble_uart_port.c ble_scan_proc.c ble_proc.c ble_msg_fifo.c ble_adv_proc.c
  group user_lib
    ../../../../../SDK_585/sdk/platform/system_library/output/Keil_5/: system_library.lib system_library_with_heap_logging.lib
    ../src/user_lib/: sharebike.lib
target dsps_586 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: dsps_586 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt"
  c include: .\..\..\..\..\..\SDK_585\\sdk\\platform\include;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\api;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_bass;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_diss;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_proxr;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_suotar;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_findme;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\src\app_custs;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\controller\em;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\controller\llc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\controller\lld;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\controller\llm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\hcic;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\hcih;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\att;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\att\attc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\att\attm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\att\atts;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gap;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gap\gapc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gap\gapm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gatt;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gatt\gattc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\gatt\gattm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\smp\smpc;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\smp\smpm;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\host\smp;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\rwble;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\rwble_hl;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\ea\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\em\api;.\..\..\..\..\..\SDK_585\\sdk\\common_project_files;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch\boot\rvds;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch\compiler\rvds;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch\ll\rvds;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch\main;.\..\..\..\..\..\SDK_585\\sdk\\platform\arch;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\arch_console;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\common\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\crypto;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\dbg\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\gtl\src;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\ke\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\ke\src;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\nvds\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\rf\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\gtl\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\rwip\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\wlan_coex;.\..\..\..\..\..\SDK_585\\sdk\\platform\core_modules\h4tl\api;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\adc;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\battery;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\gpio;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\i2c_eeprom;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\reg;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\spi;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\spi_flash;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\syscntl;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\systick;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\trng;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\uart;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\wkupct_quadec;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\ble;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\emi;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\intc;.\..\..\..\..\..\SDK_585\\sdk\\platform\driver\hw_otpc;.\..\src\config;.\..\src;..\..\..\..\..\SDK_585\\sdk\\platform\system_library\include;..\src\custom_profile;..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\lan;..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\cpp;..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\rscp;..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\pasp;..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\cscp;..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\anp;..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\hrp;.\..\..\..\..\..\SDK_585\\sdk\\app_modules\api\app_proxr;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\hci\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\hci\src;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\find;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\custom;;.\..\..\..\..\..\SDK_585\\sdk\\ble_stack\profiles\custom\custs\api;..\..\common\src;..\..\common\src\driver;..\..\common\src\profiles\spss
  library: MicroLIB
  scatter file: as above
  link misc: --feedback=".\unused.txt" .\..\..\..\..\..\SDK_585\\sdk\\common_project_files\misc\da14585_symbols.txt  --symdefs=dsps_586_symdef.txt --any_placement=best_fit --datacompressor off
